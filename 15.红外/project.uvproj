# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Listings
  asm define: 16
  group Source Group 1
    ./: main.c Delay.c Delay.h Timer.c Nix.c Timer.h Nix.h LED.h Key.h hw.c hw.h
