# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  asm define: 16
  group Source Group 1
    ./: main.c Delay.c Delay.h Timer.c Nix.c Nix.h Key.c Key.h LED.c LED.h ADC.c ADC.h GPIO.c GPIO.h
    D:/ziniao/STC8H8K64U/大二实验/3.实验三/0/: DS18B20.c DS18B20.h
